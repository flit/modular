<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sampler_k22fa12.ewp</path>
    </project>
    <batchBuild />
</workspace>
