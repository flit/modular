# IAR project sampler_k22fa12.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FX512Axxx12 NXP MK22FX512Axxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AR_ENABLE_TICKLESS_IDLE=0; CPU_MK22FX512AVLK12; __FPU_PRESENT=1; DEBUG; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa082,Pa092,Pa093
  ICCARM.CCIncludePath2: ..\..\src; ..\..\src\app; ..\..\src\app\board_k22fa12; ..\..\src\argon; ..\..\src\argon\cortex_m; ..\..\src\fatfs\src; ..\..\src\fatfs\src\fsl_sd_disk; ..\..\src\ksdk; ..\..\src\devices\MK22FA12; ..\..\src\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK22FX512AVLK12
  OBJCOPY.OOCOutputFile: sampler_k22fa12.bin
  ILINK.IlinkOutputFile: sampler_k22fa12.out
  ILINK.IlinkIcfFile: ..\..\src\devices\MK22FA12\iar\MK22FX512Axxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group app
    ../../src/app/: adc_sequencer.cpp adc_sequencer.h analog_in.cpp analog_in.h audio_defs.h audio_output.cpp audio_output.h debug_log.h file_system.cpp file_system.h led.h main.cpp microseconds.cpp microseconds.h nanolib_stubs.c pin_irq_manager.cpp pin_irq_manager.h protected_queue.h reader_thread.cpp reader_thread.h ring_buffer.h sampler_voice.cpp sampler_voice.h simple_queue.h simple_string.h stream.h utility.h wav_file.cpp wav_file.h
  group app/board_k22fa12
    ../../src/app/BOARD_K22FA12/: board.cpp board.h clock_config.h
    ../../src/app/board_k22fa12/: clock_config.c
  group argon
    ../../src/argon/cortex_m/: ar_asm_macros.h ar_atomics_cm4.S ar_handlers_cm4.S ar_port.cpp ar_port.h
    ../../src/argon/src/: ar_channel.cpp ar_config.h ar_internal.h ar_kernel.cpp ar_mutex.cpp ar_queue.cpp ar_runloop.cpp ar_sem.cpp ar_thread.cpp ar_timer.cpp
    ../../src/argon/: ar_classes.h ar_kernel.h argon.h
  group fatfs
    ../../src/fatfs/src/: argon_syscall.c diskio.c diskio.h event.c event.h ff.c ff.h ffconf.h integer.h
    ../../src/fatfs/src/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h sdhc_config.h
    ../../src/fatfs/src/option/: unicode.c
  group k22fa12
    ../../src/devices/MK22FA12/: fsl_clock.c fsl_clock.h fsl_device_registers.h MK22FA12.h MK22FA12_features.h system_MK22FA12.c system_MK22FA12.h
    ../../src/devices/MK22FA12/iar/: startup_MK22FA12.s
  group ksdk
    ../../src/ksdk/: fsl_adc16.c fsl_adc16.h fsl_card.h fsl_common.c fsl_common.h fsl_debug_console.c fsl_debug_console.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_mmc.c fsl_pit.c fsl_pit.h fsl_port.h fsl_sai.c fsl_sai.h fsl_sbrk.c fsl_sd.c fsl_sdhc.c fsl_sdhc.h fsl_sdmmc.c fsl_sdmmc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_specification.h fsl_uart.c fsl_uart.h
